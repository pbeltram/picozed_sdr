<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>grgsm_livemon_uhd</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Interactive monitor of a single C0 channel with analysis performed by Wireshark (command to run wireshark: sudo wireshark -k -f udp -Y gsmtap -i lo)</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Gr GSM Livemon</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>fc_slider</value></param>
<param><key>value</key><value>fc</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>min_len</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>800e6</value></param>
<param><key>step</key><value>2e5</value></param>
<param><key>stop</key><value>1990e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain_slider</value></param>
<param><key>value</key><value>gain</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>min_len</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.5</value></param>
<param><key>stop</key><value>50</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value>collector</value></param>
<param><key>mtu</key><value>1500</value></param>
<param><key>port</key><value>collectorport</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_CLIENT"</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>serverport</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>collector</value></param>
<param><key>label</key><value>IP or DNS name of collector point</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>localhost</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>collectorport</value></param>
<param><key>label</key><value>UDP port number of collector</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>4729</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fc</value></param>
<param><key>label</key><value>fc</value></param>
<param><key>short_id</key><value>f</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>936.6e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>gain</value></param>
<param><key>short_id</key><value>g</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>30</value></param>
</block>
<block>
<key>gsm_bcch_ccch_demapper</key>
<param><key>id</key><value>gsm_bcch_ccch_demapper_0</value></param>
<param><key>timeslot_nr</key><value>0</value></param>
</block>
<block>
<key>gsm_clock_offset_control</key>
<param><key>id</key><value>gsm_clock_offset_control_0</value></param>
<param><key>osr</key><value>osr</value></param>
<param><key>fc</key><value>fc_slider-shiftoff</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>gsm_control_channels_decoder</key>
<param><key>id</key><value>gsm_control_channels_decoder_0</value></param>
</block>
<block>
<key>gsm_control_channels_decoder</key>
<param><key>id</key><value>gsm_control_channels_decoder_1</value></param>
</block>
<block>
<key>gsm_decryption</key>
<param><key>id</key><value>gsm_decryption_0</value></param>
<param><key>a5_version</key><value>1</value></param>
<param><key>k_c</key><value>[]</value></param>
</block>
<block>
<key>gsm_input</key>
<param><key>id</key><value>gsm_input_0</value></param>
<param><key>fc</key><value>fc_slider-shiftoff</value></param>
<param><key>ppm</key><value>ppm-int(ppm)</value></param>
<param><key>samp_rate_in</key><value>samp_rate</value></param>
</block>
<block>
<key>gsm_message_printer</key>
<param><key>id</key><value>gsm_message_printer_1</value></param>
<param><key>prepend_frame_count</key><value>False</value></param>
<param><key>prepend_fnr</key><value>False</value></param>
<param><key>prepend_string</key><value>""</value></param>
<param><key>print_gsmtap_header</key><value>False</value></param>
</block>
<block>
<key>gsm_receiver</key>
<param><key>id</key><value>gsm_receiver_0</value></param>
<param><key>cell_allocation</key><value>[arfcn.downlink2arfcn(fc)]</value></param>
<param><key>osr</key><value>osr</value></param>
</block>
<block>
<key>gsm_sdcch8_demapper</key>
<param><key>id</key><value>gsm_sdcch8_demapper_0</value></param>
<param><key>timeslot_nr</key><value>1</value></param>
</block>
<block>
<key>iio_fmcomms2_source</key>
<param><key>id</key><value>iio_fmcomms2_source_0</value></param>
<param><key>bbdc</key><value>True</value></param>
<param><key>buffer_size</key><value>0x8000</value></param>
<param><key>auto_filter</key><value>True</value></param>
<param><key>gain1</key><value>"manual"</value></param>
<param><key>uri</key><value>uri</value></param>
<param><key>frequency</key><value>int(fc_slider-shiftoff)</value></param>
<param><key>manual_gain1</key><value>gain</value></param>
<param><key>quadrature</key><value>True</value></param>
<param><key>rfdc</key><value>True</value></param>
<param><key>rf_port_select</key><value>"A_BALANCED"</value></param>
<param><key>bandwidth</key><value>int(250000+abs(shiftoff))</value></param>
<param><key>rx1_en</key><value>True</value></param>
<param><key>rx2_en</key><value>False</value></param>
<param><key>samplerate</key><value>int(samp_rate)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from math import pi</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>from grgsm import arfcn</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>osr</value></param>
<param><key>label</key><value>OverSampling Ratio</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ppm</value></param>
<param><key>label</key><value>ppm</value></param>
<param><key>short_id</key><value>p</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>fc_slider</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>samp_rate</value></param>
<param><key>short_id</key><value>s</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2000000.052982</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>serverport</value></param>
<param><key>label</key><value>UDP server listening port</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>4729</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>shiftoff</value></param>
<param><key>label</key><value>Frequency Shiftoff</value></param>
<param><key>short_id</key><value>o</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>uri</value></param>
<param><key>label</key><value>URI</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>'ip:picozed'</value></param>
</block>
<connection><source_block_id>gsm_bcch_ccch_demapper_0</source_block_id><sink_block_id>gsm_control_channels_decoder_0</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_clock_offset_control_0</source_block_id><sink_block_id>gsm_input_0</sink_block_id><source_key>ctrl</source_key><sink_key>ctrl_in</sink_key></connection>
<connection><source_block_id>gsm_control_channels_decoder_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>msgs</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>gsm_control_channels_decoder_0</source_block_id><sink_block_id>gsm_message_printer_1</sink_block_id><source_key>msgs</source_key><sink_key>msgs</sink_key></connection>
<connection><source_block_id>gsm_control_channels_decoder_1</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>msgs</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>gsm_decryption_0</source_block_id><sink_block_id>gsm_control_channels_decoder_1</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_input_0</source_block_id><sink_block_id>gsm_receiver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_receiver_0</source_block_id><sink_block_id>gsm_bcch_ccch_demapper_0</sink_block_id><source_key>C0</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_receiver_0</source_block_id><sink_block_id>gsm_sdcch8_demapper_0</sink_block_id><source_key>C0</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_receiver_0</source_block_id><sink_block_id>gsm_clock_offset_control_0</sink_block_id><source_key>measurements</source_key><sink_key>measurements</sink_key></connection>
<connection><source_block_id>gsm_sdcch8_demapper_0</source_block_id><sink_block_id>gsm_decryption_0</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>iio_fmcomms2_source_0</source_block_id><sink_block_id>gsm_input_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iio_fmcomms2_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
